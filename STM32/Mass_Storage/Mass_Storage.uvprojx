# Keil uVision project Mass_Storage.uvprojx, settings and files
target STM32F103C8T6 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Mass_Storage +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\CMSIS\CoreSupport;..\DFP\2.1.0\Include;..\DFP\2.1.0\Peripherals\inc;..\DFP\STM32_USB-FS-Device_Driver\inc;.\common;.\src;.\usb
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x2400
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/CoreSupport/: core_cm3.c
    ../DFP/2.1.0/Source/ARM/: startup_stm32f10x_md.s
  group STM32F10x_StdPeriph_Driver
    ../DFP/2.1.0/Peripherals/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_flash.c
  group USB-FS-Device_Driver
    ../DFP/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB
    ./usb/: usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group Src
    ./src/: hw_config.c main.c memory.c mass_mal.c system_stm32f10x.c stm32f10x_it.c
